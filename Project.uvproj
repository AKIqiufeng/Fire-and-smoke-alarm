# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Beep.c Beep.h delay.c delay.h dht11.c dht11.h I2C.c I2C.h Key.c Key.h OLED.c OLED.h OLEDFont.h Timer0.c Timer0.h XPT2046.c XPT2046.h AT24C02.c AT24C02.h
